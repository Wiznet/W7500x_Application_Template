# Keil uVision project W7500x_Application.uvproj, settings and files
target W7500x_Application_Boot (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: W7500x_Application_Boot +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: w7500x_application_boot_gen_all_hex2bin.bat
  c flags: Optim=4
  c define: CORTEX_M0 USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS\Device\WIZnet\W7500\Include;..\..\Libraries\W7500x_stdPeriph_Driver\inc;..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\WIZnet\W7500\Source\ARM;.\src;..\..\ioLibrary\Ethernet;..\..\ioLibrary\Internet\DHCP;..\..\ioLibrary\Internet\DNS;..\..\ioLibrary\MDIO;..\..\ioLibrary\Application\loopback;.\src\Configuration;.\src\PlatformHandler;.\src\Serial_to_Ethernet;.\src\Callback;..\App\src;..\App\src\Configuration
  memory RVCT4: ROM 0x0 size 0x7000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group MDK-ARM
    ../../Libraries/CMSIS/Device/WIZnet/W7500/Source/ARM/: startup_W7500x.s
  group CMSIS
    ../../Libraries/CMSIS/Device/WIZnet/W7500/Source/: system_W7500x.c
  group W7500_Periphs
    ../../Libraries/W7500x_stdPeriph_Driver/src/: W7500x_dualtimer.c W7500x_gpio.c W7500x_uart.c W7500x_wztoe.c W7500x_crg.c
  group ioLibrary
    ../../ioLibrary/Ethernet/: socket.c wizchip_conf.c
    ../../ioLibrary/MDIO/: W7500x_miim.c
    ../../ioLibrary/Internet/DHCP/: dhcp.c
  group Callback
    ./src/Callback/: dhcp_cb.c
  group Boot_Main
    ./src/: W7500x_it.c retarget.c main.c
  group Configuration
    ./src/Configuration/: segcp.c util.c
  group PlatformHandler
    ./src/PlatformHandler/: flashHandler.c storageHandler.c timerHandler.c uartHandler.c deviceHandler.c eepromHandler.c i2cHandler.c
  group Shared_code_with_App
    ../App/src/: W7500x_board.c
    ../App/src/Configuration/: ConfigData.c
